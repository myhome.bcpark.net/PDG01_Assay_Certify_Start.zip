# CATIA V5 part "Mounting02_Part.CATPart"
Saved by CATIA V5R20 SP6, build 05-18-2011
Part number: Mounting02_Part
Stored file links:
  E:\#01 CATIA Lecture Materials\#04 ASD\#01 Certification\PDG01_Assay_Certify\Start Files\Mounting02_Part.CATPart
  E:\#01 CATIA Lecture Materials\#04 ASD\#01 Certification\PDG01_Assay_Certify\PDG01_Assay_Certify.CATProduct

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)